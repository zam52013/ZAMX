# Keil uVision project FM-Base.uvprojx, settings and files
target FM-Base-V0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FM-Base
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_FS,SYSTEM_SUPPORT_OS,__FPU_PRESENT=1,__FPU_USED =1
  c include: ..\StdPeriph_Driver_Lib\CMSIS\Include;..\StdPeriph_Driver_Lib\CMSIS\Sys;..\StdPeriph_Driver_Lib\STM32F4xx_StdPeriph_Driver\inc;..\Main;..\Board_Driver\gpio;..\Board_Driver\iic;..\Board_Driver\spi;..\Board_Driver\times;..\Board_Driver\uart;..\Board_Driver\usb;..\Board_Driver;..\StdPeriph_Driver_Lib\STM32_USB_APP\inc;..\StdPeriph_Driver_Lib\STM32_USB_Device_Library\Class\cdc\inc;..\StdPeriph_Driver_Lib\STM32_USB_Device_Library\Core\inc;..\StdPeriph_Driver_Lib\STM32_USB_OTG_Driver\inc;..\Src\drivers\FRAM;..\Src\drivers\KEY;..\Src\drivers\MPU9250;..\Src\drivers\LED;..\Src\drivers\POW_CTR;..\Src\drivers\SOUNCE;..\Planforms\UCOSII\CONFIG;..\Planforms\UCOSII\CORE;..\Planforms\UCOSII\PORT;..\Src\lib\RTCM;..\Src\lib\Conversion;..\Src\lib;..\Src\lib\LowPassFilter2p;..\Src\drivers\RTK_BASE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StdPeriph_Driver_Lib\CMSIS\Sys
    ../StdPeriph_Driver_Lib/CMSIS/Sys/: stm32f4xx_it.c system_stm32f4xx.c
  group StdPeriph_Driver_Lib\CMSIS\Core
    ../StdPeriph_Driver_Lib/CMSIS/Core/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver_Lib\STM32F4xx_StdPeriph_Driver
    ../StdPeriph_Driver_Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group StdPeriph_Driver_Lib\STM32_USB_Device_Library
    ../StdPeriph_Driver_Lib/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../StdPeriph_Driver_Lib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group StdPeriph_Driver_Lib\STM32_USB_OTG_Driver
    ../StdPeriph_Driver_Lib/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group StdPeriph_Driver_Lib\STM32_USB_APP
    ../StdPeriph_Driver_Lib/STM32_USB_APP/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group Planforms\UCOSII\CORE
    ../Planforms/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Planforms\UCOSII\CONFIG
    ../Planforms/UCOSII/CONFIG/: includes.h os_cfg.h
  group Planforms\UCOSII\PORT
    ../Planforms/UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c
  group Board_Driver
    ../Board_Driver/iic/: iic.c
    ../Board_Driver/spi/: spi.c
    ../Board_Driver/times/: times.c
    ../Board_Driver/uart/: uart.c
    ../Board_Driver/gpio/: gpio.c
  group Src\drivers
    ../Src/drivers/FRAM/: fm25v.c
    ../Src/drivers/KEY/: key.c
    ../Src/drivers/LED/: led.c
    ../Src/drivers/MPU9250/: mpu9250.c
    ../Src/drivers/POW_CTR/: pow_ctr.c
    ../Src/drivers/SOUNCE/: souce.c
    ../Src/drivers/SIM7600/: sim7600.c
    ../Src/drivers/RTK_BASE/: rtk_base.c
  group Src\lib
    ../Src/lib/RTCM/: rtcm.lib fm_qx.c socket.c
    ../Src/lib/Conversion/: rotation.c
    ../Src/lib/LowPassFilter2p/: lowpassfilter2p.c
  group Main
    ../Main/: main.c
